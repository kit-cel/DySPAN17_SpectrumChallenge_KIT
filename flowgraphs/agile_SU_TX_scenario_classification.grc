<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>agile_SU_TX_scenario_classification</value></param>
<param><key>author</key><value>Communications Engineering Lab (CEL), KIT</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>agile SU transmitter and scenario classification</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>T_disp_ms</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>aggro_mode</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>always_send</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>6, 0, 1, 1</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_configuration_new</key>
<param><key>id</key><value>cfg</value></param>
<param><key>chanmap</key><value>[1,]*128</value></param>
<param><key>bits</key><value>packetlen_base</value></param>
<param><key>overlap</key><value>4</value></param>
<param><key>sample_rate</key><value>int(samp_rate)/4</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>channel_occupation</value></param>
<param><key>block_id</key><value>scenario_classification_f</value></param>
<param><key>function_name</key><value>get_chan_occupied</value></param>
<param><key>value</key><value>None</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>ed_noisefloor</value></param>
<param><key>block_id</key><value>classifier_energy_detection_vcf_0</value></param>
<param><key>function_name</key><value>get_noisefloor_db</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>enable_tx</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>6, 2, 1, 1</value></param>
<param><key>label</key><value>enable_tx</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>equiripple_118m_132m_500m_70dB</value></param>
<param><key>value</key><value>np.array([0.00053615,0.0010861,0.0017619,0.0022328,0.0021874,0.0014325,2.9264e-05,-0.0016642,-0.0030955,-0.0037401,-0.0033511,-0.0021099,-0.00058037,0.00053299,0.00072394,-5.1054e-05,-0.001331,-0.0023721,-0.0025379,-0.0016543,-0.00013335,0.0012239,0.0016569,0.00088322,-0.00070579,-0.0022217,-0.0027558,-0.0019039,-4.0075e-05,0.0018411,0.0026556,0.0018563,-0.0002048,-0.0024103,-0.0034702,-0.002663,-0.00030483,0.0023525,0.0037801,0.0030472,0.00041551,-0.0027175,-0.0045473,-0.0038893,-0.00092515,0.0027923,0.0051404,0.0046284,0.0013257,-0.0030504,-0.0060086,-0.0056856,-0.0019949,0.0031728,0.0068949,0.0068505,0.0027389,-0.003367,-0.0080334,-0.0083676,-0.0037726,0.0034906,0.0093696,0.010241,0.0050885,-0.0036372,-0.011116,-0.012756,-0.0069285,0.0037421,0.013449,0.016255,0.0095811,-0.0038442,-0.016891,-0.021618,-0.013821,0.0039147,0.022614,0.031023,0.021695,-0.0039703,-0.034568,-0.052565,-0.041904,0.0040005,0.077685,0.15899,0.22218,0.24598,0.22218,0.15899,0.077685,0.0040005,-0.041904,-0.052565,-0.034568,-0.0039703,0.021695,0.031023,0.022614,0.0039147,-0.013821,-0.021618,-0.016891,-0.0038442,0.0095811,0.016255,0.013449,0.0037421,-0.0069285,-0.012756,-0.011116,-0.0036372,0.0050885,0.010241,0.0093696,0.0034906,-0.0037726,-0.0083676,-0.0080334,-0.003367,0.0027389,0.0068505,0.0068949,0.0031728,-0.0019949,-0.0056856,-0.0060086,-0.0030504,0.0013257,0.0046284,0.0051404,0.0027923,-0.00092515,-0.0038893,-0.0045473,-0.0027175,0.00041551,0.0030472,0.0037801,0.0023525,-0.00030483,-0.002663,-0.0034702,-0.0024103,-0.0002048,0.0018563,0.0026556,0.0018411,-4.0075e-05,-0.0019039,-0.0027558,-0.0022217,-0.00070579,0.00088322,0.0016569,0.0012239,-0.00013335,-0.0016543,-0.0025379,-0.0023721,-0.001331,-5.1054e-05,0.00072394,0.00053299,-0.00058037,-0.0021099,-0.0033511,-0.0037401,-0.0030955,-0.0016642,2.9264e-05,0.0014325,0.0021874,0.0022328,0.0017619,0.0010861,0.00053615])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>equiripple_120m_130m_500m_50dB</value></param>
<param><key>value</key><value>np.array([-0.0014851,0.00086212,0.0020139,0.003371,0.0042945,0.004268,0.0031519,0.0012954,-0.00058469,-0.0017292,-0.0017127,-0.00067235,0.00074655,0.0017187,0.0016794,0.00063719,-0.00081917,-0.0018427,-0.0018094,-0.0006915,0.0008993,0.0020404,0.0020269,0.00080008,-0.00098081,-0.0022875,-0.0023114,-0.00095804,0.0010524,0.0025628,0.0026417,0.0011508,-0.0011227,-0.0028746,-0.0030269,-0.0013845,0.0011891,0.0032208,0.0034656,0.001662,-0.001252,-0.0036075,-0.0039676,-0.0019853,0.001312,0.004044,0.0045452,0.0023677,-0.0013677,-0.0045376,-0.0052119,-0.0028195,0.0014214,0.005105,0.0059931,0.0033593,-0.0014706,-0.0057662,-0.0069199,-0.0040127,0.001516,0.0065517,0.0080409,0.0048166,-0.0015575,-0.0075094,-0.0094308,-0.005832,0.0015943,0.008713,0.01121,0.0071543,-0.0016267,-0.010291,-0.013587,-0.0089568,0.0016543,0.012479,0.016957,0.011572,-0.0016769,-0.015764,-0.022168,-0.015745,0.0016946,0.021346,0.031424,0.023544,-0.0017072,-0.033161,-0.052806,-0.04366,0.001715,0.076153,0.15907,0.22384,0.24828,0.22384,0.15907,0.076153,0.001715,-0.04366,-0.052806,-0.033161,-0.0017072,0.023544,0.031424,0.021346,0.0016946,-0.015745,-0.022168,-0.015764,-0.0016769,0.011572,0.016957,0.012479,0.0016543,-0.0089568,-0.013587,-0.010291,-0.0016267,0.0071543,0.01121,0.008713,0.0015943,-0.005832,-0.0094308,-0.0075094,-0.0015575,0.0048166,0.0080409,0.0065517,0.001516,-0.0040127,-0.0069199,-0.0057662,-0.0014706,0.0033593,0.0059931,0.005105,0.0014214,-0.0028195,-0.0052119,-0.0045376,-0.0013677,0.0023677,0.0045452,0.004044,0.001312,-0.0019853,-0.0039676,-0.0036075,-0.001252,0.001662,0.0034656,0.0032208,0.0011891,-0.0013845,-0.0030269,-0.0028746,-0.0011227,0.0011508,0.0026417,0.0025628,0.0010524,-0.00095804,-0.0023114,-0.0022875,-0.00098081,0.00080008,0.0020269,0.0020404,0.0008993,-0.0006915,-0.0018094,-0.0018427,-0.00081917,0.00063719,0.0016794,0.0017187,0.00074655,-0.00067235,-0.0017127,-0.0017292,-0.00058469,0.0012954,0.0031519,0.004268,0.0042945,0.003371,0.0020139,0.00086212,-0.0014851])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>equiripple_200m_40dB</value></param>
<param><key>value</key><value>np.array([0.0017203,-0.004888,-0.0024169,-0.0013149,-0.00035127,0.00055231,0.0011133,0.0010843,0.00046479,-0.00045283,-0.0012066,-0.0013874,-0.00085657,0.00016435,0.0011789,0.001658,0.0013103,0.00025461,-0.0010137,-0.0018499,-0.0017879,-0.00079281,0.0006859,0.0019168,0.0022418,0.0014288,-0.00018291,-0.0018133,-0.0026201,-0.0021266,-0.00049929,0.0015001,0.0028602,0.0028359,0.001342,-0.00094639,-0.0029033,-0.0034896,-0.0023145,0.00014095,0.0026852,0.0040158,0.0033609,0.00091993,-0.0021549,-0.0043271,-0.004412,-0.0022211,0.0012706,0.0043435,0.0053822,0.0037083,-3.0831e-07,-0.0039704,-0.0061663,-0.0053269,-0.0016675,0.0031223,0.0066475,0.0069883,0.0037295,-0.0017154,-0.0066927,-0.0085864,-0.0061668,-0.00033908,0.006154,0.0099952,0.0089582,0.0031476,-0.0048458,-0.011063,-0.012088,-0.0068683,0.0025123,0.011591,0.015577,0.011788,0.0012693,-0.011299,-0.019564,-0.018543,-0.0073709,0.0096666,0.024518,0.028832,0.018109,-0.0053388,-0.032129,-0.048718,-0.042578,-0.0076338,0.052308,0.12374,0.18744,0.22492,0.22492,0.18744,0.12374,0.052308,-0.0076338,-0.042578,-0.048718,-0.032129,-0.0053388,0.018109,0.028832,0.024518,0.0096666,-0.0073709,-0.018543,-0.019564,-0.011299,0.0012693,0.011788,0.015577,0.011591,0.0025123,-0.0068683,-0.012088,-0.011063,-0.0048458,0.0031476,0.0089582,0.0099952,0.006154,-0.00033908,-0.0061668,-0.0085864,-0.0066927,-0.0017154,0.0037295,0.0069883,0.0066475,0.0031223,-0.0016675,-0.0053269,-0.0061663,-0.0039704,-3.0831e-07,0.0037083,0.0053822,0.0043435,0.0012706,-0.0022211,-0.004412,-0.0043271,-0.0021549,0.00091993,0.0033609,0.0040158,0.0026852,0.00014095,-0.0023145,-0.0034896,-0.0029033,-0.00094639,0.001342,0.0028359,0.0028602,0.0015001,-0.00049929,-0.0021266,-0.0026201,-0.0018133,-0.00018291,0.0014288,0.0022418,0.0019168,0.0006859,-0.00079281,-0.0017879,-0.0018499,-0.0010137,0.00025461,0.0013103,0.001658,0.0011789,0.00016435,-0.00085657,-0.0013874,-0.0012066,-0.00045283,0.00046479,0.0010843,0.0011133,0.00055231,-0.00035127,-0.0013149,-0.0024169,-0.004888,0.0017203])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>firdes_taps</value></param>
<param><key>value</key><value>np.array([0.003524782368913293, 0.002520402194932103, -3.532667373554307e-17, -0.0025783423334360123, -0.0036887258756905794, -0.0026390093844383955, -3.7046301165340785e-18, 0.0027025998570024967, 0.003868663916364312, 0.0027693307492882013, -9.712380039780164e-18, -0.0028394402470439672, -0.004067056812345982, -0.0029131921473890543, 2.454170927498071e-17, 0.0029908770229667425, 0.004286897834390402, 0.0030728192068636417, -9.712380039780164e-18, -0.0031593774911016226, -0.004531863145530224, -0.0032509532757103443, -6.861573196148834e-18, 0.0033479968551546335, 0.004806521814316511, 0.003451012307778001, -9.712380039780164e-18, -0.0035605679731816053, -0.005116619635373354, -0.0036773078609257936, 2.849619674016194e-17, 0.003801962360739708, 0.005469490308314562, 0.003935364540666342, -9.712380039780164e-18, -0.004078468773514032, -0.0058746375143527985, -0.004232373554259539, -1.196125168755972e-17, 0.004398348741233349, 0.006344608962535858, 0.004577873274683952, -9.712380039780164e-18, -0.004772676154971123, -0.0068963137455284595, -0.004984795115888119, 3.532667373554307e-17, 0.005216646008193493, 0.00755310570821166, 0.005471116863191128, -9.712380039780164e-18, -0.0057516866363584995, -0.00834816973656416, -0.00606258912011981, 9.712380039780164e-18, 0.006409022491425276, 0.009330307133495808, 0.006797448266297579, -9.712380039780164e-18, -0.007235993165522814, -0.010574348270893097, -0.007735027000308037, 9.712380039780164e-18, 0.008307991549372673, 0.012201170437037945, 0.008972631767392159, -9.712380039780164e-18, -0.00975286029279232, -0.014419564977288246, -0.010681704618036747, 9.712380039780164e-18, 0.011806094087660313, 0.017623912543058395, 0.013195047155022621, -9.712380039780164e-18, -0.01495438627898693, -0.022659316658973694, -0.017255060374736786, 9.712380039780164e-18, 0.020392345264554024, 0.03172304481267929, 0.02492397651076317, -9.712380039780164e-18, -0.03204511106014252, -0.052871737629175186, -0.04486315697431564, 9.712380039780164e-18, 0.0747719332575798, 0.15861520171165466, 0.22431577742099762, 0.24915219843387604, 0.22431577742099762, 0.15861520171165466, 0.0747719332575798, 9.712380039780164e-18, -0.04486315697431564, -0.052871737629175186, -0.03204511106014252, -9.712380039780164e-18, 0.02492397651076317, 0.03172304481267929, 0.020392345264554024, 9.712380039780164e-18, -0.017255060374736786, -0.022659316658973694, -0.01495438627898693, -9.712380039780164e-18, 0.013195047155022621, 0.017623912543058395, 0.011806094087660313, 9.712380039780164e-18, -0.010681704618036747, -0.014419564977288246, -0.00975286029279232, -9.712380039780164e-18, 0.008972631767392159, 0.012201170437037945, 0.008307991549372673, 9.712380039780164e-18, -0.007735027000308037, -0.010574348270893097, -0.007235993165522814, -9.712380039780164e-18, 0.006797448266297579, 0.009330307133495808, 0.006409022491425276, 9.712380039780164e-18, -0.00606258912011981, -0.00834816973656416, -0.0057516866363584995, -9.712380039780164e-18, 0.005471116863191128, 0.00755310570821166, 0.005216646008193493, 3.532667373554307e-17, -0.004984795115888119, -0.0068963137455284595, -0.004772676154971123, -9.712380039780164e-18, 0.004577873274683952, 0.006344608962535858, 0.004398348741233349, -1.196125168755972e-17, -0.004232373554259539, -0.0058746375143527985, -0.004078468773514032, -9.712380039780164e-18, 0.003935364540666342, 0.005469490308314562, 0.003801962360739708, 2.849619674016194e-17, -0.0036773078609257936, -0.005116619635373354, -0.0035605679731816053, -9.712380039780164e-18, 0.003451012307778001, 0.004806521814316511, 0.0033479968551546335, -6.861573196148834e-18, -0.0032509532757103443, -0.004531863145530224, -0.0031593774911016226, -9.712380039780164e-18, 0.0030728192068636417, 0.004286897834390402, 0.0029908770229667425, 2.454170927498071e-17, -0.0029131921473890543, -0.004067056812345982, -0.0028394402470439672, -9.712380039780164e-18, 0.0027693307492882013, 0.003868663916364312, 0.0027025998570024967, -3.7046301165340785e-18, -0.0026390093844383955, -0.0036887258756905794, -0.0025783423334360123, -3.532667373554307e-17, 0.002520402194932103])*1.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-2*samp_rate</value></param>
<param><key>step</key><value>samp_rate/10</value></param>
<param><key>stop</key><value>2*samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mod_order</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nchan</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfft</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nguard_bins</value></param>
<param><key>comment</key><value>per side of the band</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nsamp_zeropadding</value></param>
<param><key>value</key><value>2320</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_interp_taps</value></param>
<param><key>value</key><value>len(taps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packetlen_base</value></param>
<param><key>value</key><value>256 * 12 * mod_order</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phydyas_taps_time</value></param>
<param><key>value</key><value>np.array(cfg.phydyas_impulse_taps(cfg.num_total_subcarriers(), cfg.num_overlap_sym()))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pu_frame_len</value></param>
<param><key>comment</key><value>at 10/nfft MS/s</value></param>
<param><key>value</key><value>80*5*9</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>pu_providedthroughput</value></param>
<param><key>block_id</key><value>classifier_packet_source_0</value></param>
<param><key>function_name</key><value>get_PU_providedthroughput</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>pu_throughput</value></param>
<param><key>block_id</key><value>classifier_packet_source_0</value></param>
<param><key>function_name</key><value>get_PU_throughput</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>.5</value></param>
<param><key>gui_hint</key><value>0, 0, 1, 1</value></param>
<param><key>label</key><value>RX gain (normalized)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.05</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(1e7)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>scenario</value></param>
<param><key>block_id</key><value>scenario_classification_f</value></param>
<param><key>function_name</key><value>get_scenario</value></param>
<param><key>value</key><value>-1</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>su_frame_len</value></param>
<param><key>comment</key><value>at 10 MS/s</value></param>
<param><key>value</key><value>(su_frame_len_low_rate + len(taps))* 4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>su_frame_len_low_rate</value></param>
<param><key>comment</key><value>at 2.5 MS/s</value></param>
<param><key>value</key><value>sync.get_frame_samps(True)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>su_providedthroughput</value></param>
<param><key>block_id</key><value>classifier_packet_source_0</value></param>
<param><key>function_name</key><value>get_providedthroughput</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>su_throughput</value></param>
<param><key>block_id</key><value>classifier_packet_source_0</value></param>
<param><key>function_name</key><value>get_throughput</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_sync_config</key>
<param><key>id</key><value>sync</value></param>
<param><key>fft_len</key><value>2**13</value></param>
<param><key>pos</key><value>4</value></param>
<param><key>A</key><value>2</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()-1</value></param>
<param><key>taps</key><value>phydyas_taps_time[1:]/np.sqrt(phydyas_taps_time.dot(phydyas_taps_time))</value></param>
<param><key>order</key><value>4</value></param>
<param><key>bands</key><value>nchan</value></param>
<param><key>guard</key><value>nguard_bins</value></param>
<param><key>bits</key><value>packetlen_base</value></param>
<param><key>overlap</key><value>4</value></param>
<param><key>pilot_A</key><value>2</value></param>
<param><key>pilot_carriers</key><value>range(8, 118, 4) + [119]</value></param>
<param><key>pilot_timestep</key><value>4</value></param>
<param><key>N</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>q</key><value>4</value></param>
<param><key>u</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tap_factor</value></param>
<param><key>value</key><value>1.8</value></param>
<param><key>label</key><value>Scale Tx Ampl.</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>2.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>equiripple_118m_132m_500m_70dB * tap_factor</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>tau</value></param>
<param><key>block_id</key><value>scenario_classification_f</value></param>
<param><key>function_name</key><value>get_tau</value></param>
<param><key>value</key><value>None</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>tau_label</value></param>
<param><key>value</key><value>tau</value></param>
<param><key>gui_hint</key><value>6, 2, 1, 1</value></param>
<param><key>label</key><value>Average Tau</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>threshold_delta</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>1, 1, 1, 1</value></param>
<param><key>label</key><value>threshold_delta</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>30</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>0.8</value></param>
<param><key>gui_hint</key><value>0, 1, 1, 1</value></param>
<param><key>label</key><value>TX gain (normalized)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.05</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>scenario</value></param>
<param><key>gui_hint</key><value>6, 1, 1, 1</value></param>
<param><key>label</key><value>Scenario</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1</value></param>
<param><key>value</key><value>channel_occupation</value></param>
<param><key>gui_hint</key><value>6, 3, 1, 1</value></param>
<param><key>label</key><value>Channel occupation</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_2</value></param>
<param><key>value</key><value>ed_noisefloor</value></param>
<param><key>gui_hint</key><value>1, 0, 1, 1</value></param>
<param><key>label</key><value>Noise floor [dB]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_2_0</value></param>
<param><key>value</key><value>pu_throughput</value></param>
<param><key>gui_hint</key><value>0, 2, 1, 1</value></param>
<param><key>label</key><value>PU throughput</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_2_0_0</value></param>
<param><key>value</key><value>pu_providedthroughput</value></param>
<param><key>gui_hint</key><value>1, 2, 1, 1</value></param>
<param><key>label</key><value>PU provided throughput</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_2_0_0_0</value></param>
<param><key>value</key><value>su_providedthroughput</value></param>
<param><key>gui_hint</key><value>1, 3, 1, 1</value></param>
<param><key>label</key><value>SU provided throughput</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_2_0_1</value></param>
<param><key>value</key><value>su_throughput</value></param>
<param><key>gui_hint</key><value>0, 3, 1, 1, </value></param>
<param><key>label</key><value>SU throughput</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0</value></param>
<param><key>bits_per_chunk</key><value>sync.get_bps()</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>nfft</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate/10</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_insert_x</key>
<param><key>id</key><value>blocks_vector_insert_x_1_0</value></param>
<param><key>offset</key><value>len(taps)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>period</key><value>su_frame_len_low_rate + len(taps)</value></param>
<param><key>vector</key><value>[0,] * len(taps)</value></param>
</block>
<block>
<key>classifier_cognitive_allocator</key>
<param><key>id</key><value>classifier_cognitive_allocator_0</value></param>
<param><key>baseband_rate</key><value>samp_rate </value></param>
<param><key>comment</key><value>Make sure the upstream block has an 
output buffer large enough
(4 * su_frame_len)

This block's stream in- and output runs at USRP samp_rate</value></param>
<param><key>detection_rate</key><value>samp_rate / nfft</value></param>
<param><key>pu_frame_len</key><value>pu_frame_len</value></param>
<param><key>su_frame_len</key><value>su_frame_len</value></param>
<param><key>aggro_mode</key><value>aggro_mode</value></param>
<param><key>always_send</key><value>always_send</value></param>
<param><key>delay_ms</key><value>1.5 + float(su_frame_len + nsamp_zeropadding) / samp_rate * 1000</value></param>
<param><key>enable_tx</key><value>enable_tx</value></param>
<param><key>nsamp_zeropadding</key><value>nsamp_zeropadding</value></param>
<param><key>wait_time_unexpected_frame_ms</key><value>50</value></param>
</block>
<block>
<key>classifier_energy_detection_vcf</key>
<param><key>id</key><value>classifier_energy_detection_vcf_0</value></param>
<param><key>nfft</key><value>nfft</value></param>
<param><key>threshold_delta_db</key><value>threshold_delta</value></param>
</block>
<block>
<key>classifier_feature_extraction_f</key>
<param><key>id</key><value>classifier_feature_extraction_f_0</value></param>
<param><key>frame_len</key><value>pu_frame_len / nfft</value></param>
<param><key>nframes</key><value>50</value></param>
<param><key>sample_rate</key><value>samp_rate / nfft</value></param>
<param><key>stepsize</key><value>5</value></param>
</block>
<block>
<key>classifier_frame_detection_f</key>
<param><key>id</key><value>classifier_frame_detection_f_0</value></param>
<param><key>lookahead</key><value>5</value></param>
<param><key>su_frame_len</key><value>(su_frame_len - nchan * len(taps) - 2 * nchan * cfg.num_total_subcarriers())/nfft - 2</value></param>
<param><key>tolerance</key><value>3</value></param>
</block>
<block>
<key>classifier_packet_source</key>
<param><key>id</key><value>classifier_packet_source_0</value></param>
<param><key>address</key><value>"192.168.52.1"</value></param>
<param><key>port</key><value>5003</value></param>
<param><key>send_state</key><value>2</value></param>
<param><key>tag_key</key><value>"packet_len"</value></param>
<param><key>isTransmitter</key><value>1</value></param>
<param><key>pkt_len</key><value>64</value></param>
</block>
<block>
<key>fbmc_subchannel_frame_generator_bvc</key>
<param><key>id</key><value>fbmc_subchannel_frame_generator_bvc_0</value></param>
<param><key>order</key><value>sync.get_bps()</value></param>
<param><key>guards</key><value>nguard_bins</value></param>
<param><key>overlap</key><value>cfg.num_overlap_sym()</value></param>
<param><key>payload_bits</key><value>cfg.num_payload_bits()</value></param>
<param><key>pilot_amp</key><value>sync.get_pilot_amplitude()</value></param>
<param><key>pilot_carriers</key><value>sync.get_pilot_carriers()</value></param>
<param><key>pilot_timestep</key><value>sync.get_pilot_timestep()</value></param>
<param><key>preamble_symbols</key><value>sync.get_preamble_symbols()</value></param>
<param><key>subcarriers</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>frame_len</key><value>sync.get_syms_frame()</value></param>
<param><key>padding</key><value>True</value></param>
</block>
<block>
<key>fbmc_tx_sdft_vcc</key>
<param><key>id</key><value>fbmc_tx_sdft_vcc_0</value></param>
<param><key>taps</key><value>phydyas_taps_time/np.sqrt(phydyas_taps_time.dot(phydyas_taps_time))/10</value></param>
<param><key>osr</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>nfft</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(nfft)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>nchan</value></param>
<param><key>minoutbuf</key><value>20* (su_frame_len + len(taps))</value></param>
<param><key>taps</key><value>taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>2, 2, 2, 2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"Input signal"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>gui_hint</key><value>4, 2, 2, 2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>name</key><value>"Binary subchannel occupation"</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>5000</value></param>
<param><key>srate</key><value>1 + 0 * samp_rate/nfft</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>gui_hint</key><value>4, 0, 2, 2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>name</key><value>"Averaged power per subchannel"</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>5000</value></param>
<param><key>srate</key><value>samp_rate // nfft</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>20</value></param>
<param><key>ymin</key><value>-50</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>3, 0, 3, 1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>name</key><value>"Average inter frame arrival time"</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>10</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value></value></param>
<param><key>ymax</key><value>2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_3</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>su_frame_len + nsamp_zeropadding</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>128</value></param>
<param><key>gui_hint</key><value>2, 0, 2, 2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"Input signal"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.05</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>scenario_classification_f</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
import scipy.stats as st
from gnuradio import gr
import pmt


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Classify scenarios"""

    def __init__(self, tconst=2, tau1=5, tau2=10, lambda1=20, lambda2=50, lambda3=100):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Scenario classification',   # will show up in GRC
            in_sig=[np.float32]*6,
            out_sig=None
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.tconst = tconst
        self.tau1 = tau1
        self.tau2 = tau2
        self.lambda1 = lambda1
        self.lambda2 = lambda2
        self.lambda3 = lambda3
        self.nchan = 4
        self.scenario_tau = np.array([self.tau1, self.tau2, 2*self.tau1, 4*self.tau2, self.tau1, self.tau1, self.tconst, self.lambda1, self.lambda2, self.lambda3, 0])  # scenario 10 is "unsure, don't send"
        self.scenario_send_window = self.scenario_tau.copy()  # the send window for the hopping and Poisson scenarios differs from the deterministic ones
        self.scenario_send_window[2] = self.tau1
        self.scenario_send_window[3] = self.tau2
        for i in range(7, 10):
          self.scenario_send_window[i] = st.poisson.ppf(0.05, self.scenario_tau[i])
        print "expected mean inter frame times: ", self.scenario_tau
        print "send windows: ", self.scenario_send_window
        
        self.max_confidence = 3
        self.confidence = 0
        
        self.scenario = 10
        self.chan_occupied = [False] * self.nchan  # list of true/false values
        self.tau = None
        
        self.message_port_register_out(pmt.intern("scenario"))
        
    def get_scenario(self):
        return self.scenario
        
    def get_chan_occupied(self):
            return [i for i in range(self.nchan) if self.chan_occupied[i]]
        
    def get_tau(self):
        return self.tau
        
    def run_decision_tree(self, inter_frame_times, inter_frame_time_variance):
        chan_occupied = list(inter_frame_times &gt;= 0)  # all channels that have an inter frame arrival time &gt; 0 are regarded as being occupied FIXME: handle wildly different values as being false (e.g., due to one channel no longer being used)
        nchan_occupied = sum(chan_occupied)  # number of occupied channels
        self.tau = np.mean([inter_frame_times[i] for i in range(self.nchan) if chan_occupied[i]])  # inter arrival time averaged over occupied channels
        delta_tau = abs(self.tau - self.scenario_tau)
        
        if nchan_occupied == 1:  # possible scenarios: 0 or 1 (deterministic transmission with tau1 or tau2 on a single channel, respectively)
            possible_scenarios = [0, 1]
            idx = np.argmin([delta_tau[i] for i in possible_scenarios])
            s = possible_scenarios[idx]
        elif nchan_occupied == 2:  # possible scenarios: 2 or 4 (hopping or deterministic with tau1 on two channels, respectively)
            possible_scenarios = [2, 4]
            idx = np.argmin([delta_tau[i] for i in possible_scenarios])
            s = possible_scenarios[idx]
        elif nchan_occupied == 4:  # possible scenarios: 6 (all channels deterministic with tconst), 5 (all channels deterministic with tau1), 3 (all channels hopping with tau1), 7-9 (all channels, Poisson process with different lambdas)
            possible_scenarios = [3, 5, 6, 7, 8, 9]
            idx = np.argmin([delta_tau[i] for i in possible_scenarios])
            if possible_scenarios[idx] == 5 or possible_scenarios[idx] == 9:  # they have the same mean interarrival time, decide based on the variance
              if inter_frame_time_variance &gt; float(self.scenario_tau[9])/2:  # considerable variance indicates the non-deterministic Poisson scenario (expected variance is equal to the mean interframe time)
                s = 9
              else:
                s = 5
            else:
              s = possible_scenarios[idx]
        else:  # 0 or 3 occupied channels is not a valid scenario
            chan_occupied = list([True for i in range(self.nchan)])
            s = 10  # unknown scenario, possible in the process of changing
            
        return s, chan_occupied
        
    def post_message(self):
        msg_dict = pmt.make_dict()
        msg_dict = pmt.dict_add(msg_dict, pmt.intern("scenario_number"), pmt.from_long(long(self.scenario)))
        msg_dict = pmt.dict_add(msg_dict, pmt.intern("scenario_channels"), pmt.to_pmt([bool(c) for c in self.chan_occupied]))
        msg_dict = pmt.dict_add(msg_dict, pmt.intern("scenario_tau"), pmt.from_long(long(self.scenario_send_window[self.scenario])))
        self.message_port_pub(pmt.intern("scenario"), msg_dict)

    def work(self, input_items, output_items):
        inter_frame_times = np.array([input_items[i][0] for i in range(self.nchan)])  # current inter frame arrival time per channel
        packet_rate = input_items[4][0]  # not used at the moment
        inter_frame_time_variance = input_items[5][0]  # variance of the inter frame arrival time (averaged over all channels)
        detected_scenario, chan_occupied = self.run_decision_tree(inter_frame_times, inter_frame_time_variance)
        if detected_scenario != self.scenario or chan_occupied != self.chan_occupied:
            self.confidence -= 1
            if self.confidence &lt; 0:
                self.scenario = detected_scenario
                self.chan_occupied = chan_occupied
                self.confidence = 0
                self.post_message()
        else:
           self.confidence = min(self.confidence + 1, self.max_confidence)
        return 1
</value></param>
<param><key>lambda1</key><value>20</value></param>
<param><key>lambda2</key><value>10</value></param>
<param><key>lambda3</key><value>5</value></param>
<param><key>tau1</key><value>5</value></param>
<param><key>tau2</key><value>10</value></param>
<param><key>tconst</key><value>2</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_1_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(3.195e9, samp_rate)</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>type=b200</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source0</key><value>gpsdo</value></param>
<param><key>sd_spec0</key><value>A:A</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(3.195e9, lo_offset)</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>type=b200</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>gpsdo</value></param>
<param><key>sd_spec0</key><value>A:B</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>en_0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>en_1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>en_2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0</value></param>
<param><key>stream_id</key><value>en_3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>en_0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>en_3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>en_1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_4</value></param>
<param><key>stream_id</key><value>en_2</value></param>
</block>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0</source_block_id><sink_block_id>fbmc_subchannel_frame_generator_bvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_insert_x_1_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_cognitive_allocator_0</source_block_id><sink_block_id>qtgui_time_sink_x_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_cognitive_allocator_0</source_block_id><sink_block_id>uhd_usrp_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>5</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>6</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>7</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0</sink_block_id><source_key>7</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>scenario_classification_f</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>scenario_classification_f</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>scenario_classification_f</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>scenario_classification_f</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>scenario_classification_f</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>scenario_classification_f</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>classifier_frame_detection_f_0</source_block_id><sink_block_id>classifier_feature_extraction_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_frame_detection_f_0</source_block_id><sink_block_id>classifier_feature_extraction_f_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>classifier_frame_detection_f_0</source_block_id><sink_block_id>classifier_cognitive_allocator_0</sink_block_id><source_key>pu_frame_start</source_key><sink_key>pu_frame_start</sink_key></connection>
<connection><source_block_id>classifier_packet_source_0</source_block_id><sink_block_id>classifier_cognitive_allocator_0</sink_block_id><source_key>enable_tx</source_key><sink_key>enable_tx</sink_key></connection>
<connection><source_block_id>classifier_packet_source_0</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_subchannel_frame_generator_bvc_0</source_block_id><sink_block_id>fbmc_tx_sdft_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_tx_sdft_vcc_0</source_block_id><sink_block_id>blocks_vector_insert_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>classifier_energy_detection_vcf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>classifier_cognitive_allocator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>scenario_classification_f</source_block_id><sink_block_id>classifier_cognitive_allocator_0</sink_block_id><source_key>scenario</source_key><sink_key>scenario</sink_key></connection>
<connection><source_block_id>scenario_classification_f</source_block_id><sink_block_id>classifier_packet_source_0</sink_block_id><source_key>scenario</source_key><sink_key>scenario</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>classifier_frame_detection_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>classifier_frame_detection_f_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>classifier_frame_detection_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_4</source_block_id><sink_block_id>classifier_frame_detection_f_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
</flow_graph>
